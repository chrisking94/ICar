# Keil uVision project 智能车.uvproj, settings and files
target IntelligentCar (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ICHex +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Core;..\Lib\inc;..\MyCode
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../CORE/: core_cm3.c
    ../Core/: startup_stm32f10x_md.s system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c
  group Mycode
    ../MyCode/: usart.c L298N.c Common.c I2C.c SPI.c Screen.c ds3231.c UltrasonicSystem.c
  group User
    ./: main.c
