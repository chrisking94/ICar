# Keil uVision project ICarScreen.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ICarScreen +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: Common.c Font.c LCD1.8.c LCD1.8_TextField.c SPI.c main.c
  group New Group
    ./: AT24C32.h Common.h DS3231.h Font.h I2C.h LCD1.8.h SPI.h
